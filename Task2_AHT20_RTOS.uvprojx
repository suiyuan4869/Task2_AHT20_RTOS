# Keil uVision project Task2_AHT20_RTOS.uvprojx, settings and files
target Task2_AHT20_uCOSIII (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: Task2_AHT20 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\App;.\BSP;.\Drivers;.\Libraries\CMSIS;.\Libraries\StdPeriph\inc;.\UCOSIII\uC-CPU;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;.\UCOSIII\uC-LIB;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\UCOSIII\uCOS_CONFIG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/: main.c app.c app.h
  group BSP
    ./BSP/: bsp.c bsp.h delay.c delay.h dwt.h led.c led.h uart.c uart.h
  group Drivers
    ./Drivers/: i2c_soft.c i2c_soft.h aht20.c aht20.h
  group Startup
    ./Startup/: startup_stm32f10x_md.s
    ./Libraries/CMSIS/: system_stm32f10x.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.h stm32f10x_conf.h
  group StdPeriph
    ./Libraries/StdPeriph/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group UCOSIII_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c cpu.h
  group UCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group UCOSIII_CONFIG
    ./UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
